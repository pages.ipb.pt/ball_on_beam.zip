simulink library "cdigital"  (Simulink 3.00)
libraries: ballbeam x1

== system cdigital ==
  Ball on Beam : ballbeam/Ball on Beam
